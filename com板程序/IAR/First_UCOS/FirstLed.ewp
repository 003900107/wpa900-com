# IAR project FirstLed.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: STM32F107xC ST STM32F107xC
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Full.h
  ICCARM.CCDefines: USE_STDPERIPH_DRIVER; STM32F10X_CL
  ICCARM.CCIncludePath2: APP; ..\BSP; ..\..\CPU\STM32F10x_StdPeriph_Driver\inc; ..\..\CPU\CMSIS\CM3\CoreSupport; ..\..\CPU\CMSIS\CM3\DeviceSupport\ST\STM32F10x; ..\..\CPU\ETH\inc; ..\BSP\uCOS-II; ..\..\uCOS-II\Ports\ARM-Cortex-M3\Generic\IAR; ..\..\uCOS-II\Source; ..\..\uC-LIB; ..\..\uC-LIB\Ports\ARM-Cortex-M3\IAR; ..\..\uC-CPU; ..\..\uC-CPU\ARM-Cortex-M3\IAR; ..\..\lwIP\port\include; ..\..\lwIP\port\include\; ..\..\lwIP\port\include\netif; ..\..\lwIP\src\include; ..\..\lwIP\src\include\ipv4; ..\..\lwIP\src\include\lwip
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: FirstLed.hex
  ILINK.IlinkOutputFile: FirstLed.out
  ILINK.IlinkIcfFile: C:\Users\Administrator.WUQ6BOGNM6KUZK8\Desktop\com板程序\IAR\BSP\stm32f10x_flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCOptLevel: 3
  group APP
    APP/: app.c app_hooks.c app_vect.c console.c helloworld.c RtuClient.c TcpClient.c
  group BSP/BSP
    ../BSP/: bsp.c bsp_int.c ENC28J60.C stm3210c_eval_lcd.c stm32_eval.c
  group BSP/STM32Lib/CMSIS
    ../../CPU/CMSIS/CM3/CoreSupport/: core_cm3.c
    ../../CPU/CMSIS/CM3/DeviceSupport/ST/STM32F10x/: system_stm32f10x.c
  group BSP/STM32Lib/StdPeriphDriver
    ../../CPU/STM32F10x_StdPeriph_Driver/src/: misc.c stm32f10x_adc.c stm32f10x_exti.c stm32f10x_flash.c stm32f10x_gpio.c stm32f10x_rcc.c stm32f10x_spi.c stm32f10x_tim.c stm32f10x_usart.c
  group ETHLib/inc
    ../../CPU/ETH/inc/: stm32_eth.h
  group ETHLib/src
    ../../CPU/ETH/src/: stm32_eth.c
  group LwIP/Ports
    ../../lwIP/port/netif/: ethernetif.c
    ../../lwIP/port/: lwIP.c sys_arch.c
    ../../lwIP/port/include/: lwipopts.h
  group LwIP/Source/api
    ../../lwIP/src/api/: api_lib.c api_msg.c err.c netbuf.c netdb.c netifapi.c sockets.c tcpip.c
  group LwIP/Source/core
    ../../lwIP/src/core/: dhcp.c dns.c init.c mem.c memp.c netif.c pbuf.c raw.c stats.c sys.c tcp.c tcp_in.c tcp_out.c udp.c
  group LwIP/Source/core/ipv4
    ../../lwIP/src/core/ipv4/: autoip.c icmp.c igmp.c inet.c inet_chksum.c ip.c ip_addr.c ip_frag.c
  group LwIP/Source/netif
    ../../lwIP/src/netif/: etharp.c
  group Modbus
    APP/: modbus_rtu_master.c modbus_tcp_master.c
  group uC/CPU/Ports
    ../../uC-CPU/ARM-Cortex-M3/IAR/: cpu.h cpu_a.asm cpu_c.c
  group uC/CPU/Source
    ../../uC-CPU/: cpu_core.c cpu_core.h cpu_def.h
  group uC/LIB/PORTS
    ../../uC-LIB/Ports/ARM-Cortex-M3/IAR/: lib_mem_a.asm
  group uC/LIB/Source
    ../../uC-LIB/: lib_ascii.c lib_math.c lib_mem.c lib_str.c
  group uC/OS-II/Ports
    ../../uCOS-II/Ports/ARM-Cortex-M3/Generic/IAR/: os_cpu.h os_cpu_a.asm os_cpu_c.c os_dbg.c
  group uC/OS-II/Source
    ../../uCOS-II/Source/: os_core.c os_flag.c os_mbox.c os_mem.c os_mutex.c os_q.c os_sem.c os_task.c os_time.c os_tmr.c ucos_ii.h
